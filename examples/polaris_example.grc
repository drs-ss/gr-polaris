<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>polaris_example</value></param>
<param><key>author</key><value>drs</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>A simple example graph to output two complex streams of data from the polaris source block.</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Polaris Source Example</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_1</value></param>
<param><key>value</key><value>100000000</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>min_len</key><value>500</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>2e6</value></param>
<param><key>step</key><value>1e6</value></param>
<param><key>stop</key><value>6200e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_2</value></param>
<param><key>value</key><value>100000000</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>min_len</key><value>500</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>2e6</value></param>
<param><key>step</key><value>100e3</value></param>
<param><key>stop</key><value>6200e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_3</value></param>
<param><key>value</key><value>164000000</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>min_len</key><value>500</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>2e6</value></param>
<param><key>step</key><value>100e3</value></param>
<param><key>stop</key><value>6200e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_4</value></param>
<param><key>value</key><value>111500000</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
<param><key>min_len</key><value>500</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>2e6</value></param>
<param><key>step</key><value>100000</value></param>
<param><key>stop</key><value>6200e6</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>preamp1</value></param>
<param><key>value</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>label0</key><value>True</value></param>
<param><key>label1</key><value>False</value></param>
<param><key>label</key><value>Enable Preamp 1</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>True</value></param>
<param><key>option1</key><value>False</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>preamp2</value></param>
<param><key>value</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,3,1,1</value></param>
<param><key>label0</key><value>True</value></param>
<param><key>label1</key><value>False</value></param>
<param><key>label</key><value>Enable Preamp 2</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>True</value></param>
<param><key>option1</key><value>False</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>preamp3</value></param>
<param><key>value</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
<param><key>label0</key><value>True</value></param>
<param><key>label1</key><value>False</value></param>
<param><key>label</key><value>Enable Preamp 3</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>True</value></param>
<param><key>option1</key><value>False</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>preamp4</value></param>
<param><key>value</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>3,3,1,1</value></param>
<param><key>label0</key><value>True</value></param>
<param><key>label1</key><value>False</value></param>
<param><key>label</key><value>Enable Preamp 4</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>True</value></param>
<param><key>option1</key><value>False</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>64e6</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>9000</value></param>
<param><key>step</key><value>1e5</value></param>
<param><key>stop</key><value>128e6</value></param>
</block>
<block>
<key>fosphor_qt_sink_c</key>
<param><key>id</key><value>fosphor_qt_sink_c_0_0</value></param>
<param><key>freq_center</key><value>freq_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq_span</key><value>samp_rate_1</value></param>
</block>
<block>
<key>polaris_polaris_src</key>
<param><key>id</key><value>polaris_polaris_src_0</value></param>
<param><key>stream_port</key><value>4991</value></param>
<param><key>flex_port</key><value>4992</value></param>
<param><key>flex_num_streams</key><value>0</value></param>
<param><key>numddc1</key><value>1</value></param>
<param><key>valuea1</key><value>0</value></param>
<param><key>valueg1d1f</key><value>0</value></param>
<param><key>valueg1d1sr</key><value>10000000</value></param>
<param><key>valueg1d2f</key><value>0</value></param>
<param><key>valueg1d2sr</key><value>10000000</value></param>
<param><key>valuepa1</key><value>False</value></param>
<param><key>valuetf1</key><value>100000000</value></param>
<param><key>valuet1</key><value>4</value></param>
<param><key>valueg2d1f</key><value>0</value></param>
<param><key>valueg2d1sr</key><value>10000000</value></param>
<param><key>valueg2d2f</key><value>0</value></param>
<param><key>valueg2d2sr</key><value>10000000</value></param>
<param><key>valueg3d1f</key><value>0</value></param>
<param><key>valueg3d1sr</key><value>10000000</value></param>
<param><key>valueg3d2f</key><value>0</value></param>
<param><key>valueg3d2sr</key><value>10000000</value></param>
<param><key>valueg4d1f</key><value>0</value></param>
<param><key>valueg4d1sr</key><value>10000000</value></param>
<param><key>valueg4d2f</key><value>0</value></param>
<param><key>valueg4d2sr</key><value>10000000</value></param>
<param><key>i_op</key><value>True</value></param>
<param><key>fiber_ip</key><value>192.168.11.71</value></param>
<param><key>mne_port</key><value>8081</value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>phys</key><value>0</value></param>
<param><key>stream_ip</key><value>192.168.11.61</value></param>
<param><key>dev_ip</key><value>192.168.10.50</value></param>
<param><key>flex_1_ave</key><value>1</value></param>
<param><key>flex_1_complex</key><value>1</value></param>
<param><key>flex_1_rate</key><value>10</value></param>
<param><key>flex_1_size</key><value>128</value></param>
<param><key>flex_1_src</key><value>0</value></param>
<param><key>flex_2_ave</key><value>1</value></param>
<param><key>flex_2_complex</key><value>1</value></param>
<param><key>flex_2_rate</key><value>10</value></param>
<param><key>flex_2_size</key><value>128</value></param>
<param><key>flex_2_src</key><value>3</value></param>
<param><key>flex_3_ave</key><value>1</value></param>
<param><key>flex_3_complex</key><value>1</value></param>
<param><key>flex_3_rate</key><value>10</value></param>
<param><key>flex_3_size</key><value>128</value></param>
<param><key>flex_3_src</key><value>6</value></param>
<param><key>flex_4_ave</key><value>1</value></param>
<param><key>flex_4_complex</key><value>1</value></param>
<param><key>flex_4_rate</key><value>10</value></param>
<param><key>flex_4_size</key><value>128</value></param>
<param><key>flex_4_src</key><value>9</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>freq_1</value></param>
<param><key>affinity</key><value>2</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>name</key><value>"Tuner 1"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>polaris_polaris_src_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
